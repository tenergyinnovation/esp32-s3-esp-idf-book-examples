/* oled.c — เก็บภาพไว้ใน buffer 1024 bytes ก่อน แล้วค่อยส่งขึ้นจอทีเดียว (เหมือนวาดบนกระดาษทดก่อนติดบอร์ด) */
#include <string.h>
#include "oled.h"
#include "esp_lcd_panel_io.h"
#include "esp_lcd_panel_ops.h"
#include "esp_lcd_panel_ssd1306.h"
#define OLED_TRY(x) do { esp_err_t e_ = (x); if (e_ != ESP_OK) return e_; } while (0)

static esp_lcd_panel_handle_t s_panel;
static uint8_t s_buf[OLED_W * OLED_H / 8];     /* 1 bit ต่อ pixel = 1024 bytes */

/* ฟอนต์ 5x7 ASCII 0x20..0x7E (5 คอลัมน์ต่อตัว บิตล่างสุด = แถวบน) */
static const uint8_t FONT5X7[] = {
0x00,0x00,0x00,0x00,0x00, 0x00,0x00,0x5F,0x00,0x00, 0x00,0x07,0x00,0x07,0x00, 0x14,0x7F,0x14,0x7F,0x14,
0x24,0x2A,0x7F,0x2A,0x12, 0x23,0x13,0x08,0x64,0x62, 0x36,0x49,0x55,0x22,0x50, 0x00,0x05,0x03,0x00,0x00,
0x00,0x1C,0x22,0x41,0x00, 0x00,0x41,0x22,0x1C,0x00, 0x08,0x2A,0x1C,0x2A,0x08, 0x08,0x08,0x3E,0x08,0x08,
0x00,0x50,0x30,0x00,0x00, 0x08,0x08,0x08,0x08,0x08, 0x00,0x60,0x60,0x00,0x00, 0x20,0x10,0x08,0x04,0x02,
0x3E,0x51,0x49,0x45,0x3E, 0x00,0x42,0x7F,0x40,0x00, 0x42,0x61,0x51,0x49,0x46, 0x21,0x41,0x45,0x4B,0x31,
0x18,0x14,0x12,0x7F,0x10, 0x27,0x45,0x45,0x45,0x39, 0x3C,0x4A,0x49,0x49,0x30, 0x01,0x71,0x09,0x05,0x03,
0x36,0x49,0x49,0x49,0x36, 0x06,0x49,0x49,0x29,0x1E, 0x00,0x36,0x36,0x00,0x00, 0x00,0x56,0x36,0x00,0x00,
0x00,0x08,0x14,0x22,0x41, 0x14,0x14,0x14,0x14,0x14, 0x41,0x22,0x14,0x08,0x00, 0x02,0x01,0x51,0x09,0x06,
0x32,0x49,0x79,0x41,0x3E, 0x7E,0x11,0x11,0x11,0x7E, 0x7F,0x49,0x49,0x49,0x36, 0x3E,0x41,0x41,0x41,0x22,
0x7F,0x41,0x41,0x22,0x1C, 0x7F,0x49,0x49,0x49,0x41, 0x7F,0x09,0x09,0x01,0x01, 0x3E,0x41,0x41,0x51,0x32,
0x7F,0x08,0x08,0x08,0x7F, 0x00,0x41,0x7F,0x41,0x00, 0x20,0x40,0x41,0x3F,0x01, 0x7F,0x08,0x14,0x22,0x41,
0x7F,0x40,0x40,0x40,0x40, 0x7F,0x02,0x04,0x02,0x7F, 0x7F,0x04,0x08,0x10,0x7F, 0x3E,0x41,0x41,0x41,0x3E,
0x7F,0x09,0x09,0x09,0x06, 0x3E,0x41,0x51,0x21,0x5E, 0x7F,0x09,0x19,0x29,0x46, 0x46,0x49,0x49,0x49,0x31,
0x01,0x01,0x7F,0x01,0x01, 0x3F,0x40,0x40,0x40,0x3F, 0x1F,0x20,0x40,0x20,0x1F, 0x7F,0x20,0x18,0x20,0x7F,
0x63,0x14,0x08,0x14,0x63, 0x03,0x04,0x78,0x04,0x03, 0x61,0x51,0x49,0x45,0x43, 0x00,0x00,0x7F,0x41,0x41,
0x02,0x04,0x08,0x10,0x20, 0x41,0x41,0x7F,0x00,0x00, 0x04,0x02,0x01,0x02,0x04, 0x40,0x40,0x40,0x40,0x40,
0x00,0x01,0x02,0x04,0x00, 0x20,0x54,0x54,0x54,0x78, 0x7F,0x48,0x44,0x44,0x38, 0x38,0x44,0x44,0x44,0x20,
0x38,0x44,0x44,0x48,0x7F, 0x38,0x54,0x54,0x54,0x18, 0x08,0x7E,0x09,0x01,0x02, 0x08,0x14,0x54,0x54,0x3C,
0x7F,0x08,0x04,0x04,0x78, 0x00,0x44,0x7D,0x40,0x00, 0x20,0x40,0x44,0x3D,0x00, 0x00,0x7F,0x10,0x28,0x44,
0x00,0x41,0x7F,0x40,0x00, 0x7C,0x04,0x18,0x04,0x78, 0x7C,0x08,0x04,0x04,0x78, 0x38,0x44,0x44,0x44,0x38,
0x7C,0x14,0x14,0x14,0x08, 0x08,0x14,0x14,0x18,0x7C, 0x7C,0x08,0x04,0x04,0x08, 0x48,0x54,0x54,0x54,0x20,
0x04,0x3F,0x44,0x40,0x20, 0x3C,0x40,0x40,0x20,0x7C, 0x1C,0x20,0x40,0x20,0x1C, 0x3C,0x40,0x30,0x40,0x3C,
0x44,0x28,0x10,0x28,0x44, 0x0C,0x50,0x50,0x50,0x3C, 0x44,0x64,0x54,0x4C,0x44, 0x00,0x08,0x36,0x41,0x00,
0x00,0x00,0x7F,0x00,0x00, 0x00,0x41,0x36,0x08,0x00, 0x08,0x08,0x2A,0x1C,0x08,
};

esp_err_t oled_init(i2c_master_bus_handle_t bus, uint8_t addr)
{
    esp_lcd_panel_io_handle_t io;
    esp_lcd_panel_io_i2c_config_t io_cfg = {
        .dev_addr = addr, .scl_speed_hz = 400000, .control_phase_bytes = 1,
        .lcd_cmd_bits = 8, .lcd_param_bits = 8, .dc_bit_offset = 6,      /* ตาม datasheet SSD1306 */
    };
    OLED_TRY(esp_lcd_new_panel_io_i2c(bus, &io_cfg, &io));
    esp_lcd_panel_ssd1306_config_t vcfg = { .height = OLED_H };
    esp_lcd_panel_dev_config_t pcfg = { .bits_per_pixel = 1, .reset_gpio_num = -1, .vendor_config = &vcfg };
    OLED_TRY(esp_lcd_new_panel_ssd1306(io, &pcfg, &s_panel));
    OLED_TRY(esp_lcd_panel_reset(s_panel));
    OLED_TRY(esp_lcd_panel_init(s_panel));
    /* ไดรเวอร์ตั้งค่าเริ่มต้นเป็นไม่กลับด้าน (0xA0/0xC0) โมดูล 0.96" ทั่วไปที่ขาอยู่ด้านบนจะเห็นภาพกลับหัว
       กลับทั้งแกน X และ Y (0xA1/0xC8) ให้ข้อความตั้งตรง ถ้าโมดูลของคุณกลับหัวให้เปลี่ยนเป็น false, false */
    OLED_TRY(esp_lcd_panel_mirror(s_panel, true, true));
    OLED_TRY(esp_lcd_panel_disp_on_off(s_panel, true));
    oled_clear();
    return oled_flush();
}

void oled_clear(void) { memset(s_buf, 0, sizeof(s_buf)); }

void oled_pixel(int x, int y, bool on)
{
    if (x < 0 || x >= OLED_W || y < 0 || y >= OLED_H) return;
    uint8_t *b = &s_buf[(y / 8) * OLED_W + x];
    if (on) *b |= 1 << (y % 8); else *b &= ~(1 << (y % 8));
}

void oled_text(int x, int page, const char *s)
{
    for (; *s && x <= OLED_W - 6; s++, x += 6) {
        char c = (*s < 0x20 || *s > 0x7E) ? '?' : *s;
        memcpy(&s_buf[page * OLED_W + x], &FONT5X7[(c - 0x20) * 5], 5);
    }
}

void oled_text_big(int x, int page, const char *s)
{
    for (; *s && x <= OLED_W - 12; s++, x += 12) {
        char c = (*s < 0x20 || *s > 0x7E) ? '?' : *s;
        const uint8_t *g = &FONT5X7[(c - 0x20) * 5];
        for (int col = 0; col < 5; col++)
            for (int row = 0; row < 8; row++)
                if (g[col] & (1 << row))
                    for (int dx = 0; dx < 2; dx++)
                        for (int dy = 0; dy < 2; dy++) oled_pixel(x + col * 2 + dx, page * 8 + row * 2 + dy, true);
    }
}

void oled_rect(int x, int y, int w, int h, bool fill)
{
    for (int i = x; i < x + w; i++)
        for (int j = y; j < y + h; j++)
            if (fill || i == x || i == x + w - 1 || j == y || j == y + h - 1) oled_pixel(i, j, true);
}

esp_err_t oled_flush(void)
{
    return esp_lcd_panel_draw_bitmap(s_panel, 0, 0, OLED_W, OLED_H, s_buf);
}
